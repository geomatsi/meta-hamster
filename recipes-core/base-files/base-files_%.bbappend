#
#
#

hostname = "${MACHINE}-iot-hub"
